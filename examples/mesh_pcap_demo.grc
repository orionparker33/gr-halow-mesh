options:
  parameters:
    author: gr-halow-mesh contributors
    category: Custom
    description: Offline radiotap PCAP to 802.11s mesh parser demo
    generate_options: no_gui
    id: halow_mesh_pcap_demo
    output_language: python
    title: HaLow Mesh PCAP Demo
  states: {}

blocks:
- name: halow_mesh_pcap_source_0
  id: halow_mesh_pcap_source
  parameters:
    path: capture.pcap
  states: {}
- name: halow_mesh_decode_0
  id: halow_mesh_decode
  parameters:
    emit_all: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [halow_mesh_pcap_source_0, out, halow_mesh_decode_0, in]
- [halow_mesh_decode_0, events, blocks_message_debug_0, print]

metadata:
  file_format: 1
